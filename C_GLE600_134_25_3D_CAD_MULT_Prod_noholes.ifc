Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:29:59
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:29:59 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{F86F8379-7006-4B88-8513-B6370D23DEA8}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:29:59 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:29:59 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:29:59 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Remove Holes\RFA 3D\GLE600_134_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Pattern: -3000010; Color: 0; Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: GLE600_134_25, GLE600_134_25:GLE600_134_25:167215
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00481164 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE600/134/2.5
Identity Data - Name: GLE600/134/2.5; Model ID: 0200181214085717154208661832541747226109; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; ObjectType: GLE600/134/2.5; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Copyright: ©Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; Description: Joist hanger; Model: GLE600/134/2.5; Manufacturer: Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; URL: www.strongtie.eu
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GLE600/134/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 0.983
Materials and Finishes - Product Material: Galvanised
